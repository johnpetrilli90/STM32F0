# Keil uVision project TEC_Cooler_FW.uvproj, settings and files
target STM32F030 CPU Controller (ARM-ADS)
  device: STM32F030K6 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: TEC_FW_v004 +hex
  c flags: Optim=1 OneElfS=1
  c include: .\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7fff
  memory RVCT9: RAM 0x20000000 size 0x1800
  group StartUp
    ./: startup_stm32f030.s system_stm32f0xx.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group Source Files
    ./Source/: ADC.c ClockConfig.c Communication.c Flash.c InitIO.c IRQn.c Main.c PID.c UART.c WatchDog.c
  group Include Files
    ./Include/: ADC.h ClockConfig.h Communication.h Flash.h InitIO.h IRQn.h PID.h UART.h WatchDog.h
  group Documentation
    ./: ReadMe.txt
